# Keil uVision project iot.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iot +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,DEBUG
  c include: .\include;.\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c startup_stm32f10x_md.s cmd.h cmd.c md5.c md5.h core.c core.h
  group HARDWARE
    ./HARDWARE/: usart.c usart.h dma.h dma.c timer.c timer.h exti.h exti.c stmflash.c stmflash.h rtc.h sys.h sys.c rtc.c esp8266.c esp8266.h
